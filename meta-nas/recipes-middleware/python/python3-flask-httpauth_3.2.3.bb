DESCRIPTION = "Basic and Digest HTTP authentication for Flask routes"
HOMEPAGE = "http://github.com/miguelgrinberg/flask-httpauth/"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3b69377f79f3f48c661701236d5a6a85"
SRC_URI[md5sum] = "20f31ed9eb28ca04de57bece707c63d7"
PYPI_PACKAGE = "Flask-HTTPAuth"
inherit pypi setuptools3
