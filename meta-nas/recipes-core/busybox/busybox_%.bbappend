FILESEXTRAPATHS_prepend := "${THISDIR}/:"
SRC_URI += " \
            file://httpd.cfg \
            file://chpasswd.cfg \
           "
